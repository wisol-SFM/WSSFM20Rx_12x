# Keil uVision project direct_test_mode_pca10040_s132.uvprojx, settings and files
target nrf52832_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  AfterMake: .\sigfox_cfg2_binary_copy.bat "#H"
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD NRF52832 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_SD_BLE_API_VERSION=3 NRF52 SOFTDEVICE_PRESENT NRF_DFU_SETTINGS_VERSION=1  FEATURE_WISOL_DEVICE
  c include: ..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..;..\config;..\..\..\..\source;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\examples\bsp;..\..\..\..\..\..\components\drivers_nrf\common
  asm define: BLE_STACK_SUPPORT_REQD NRF52832 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_SD_BLE_API_VERSION=3 BSP_DEFINES_ONLY NRF52 SOFTDEVICE_PRESENT
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF52832,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_30,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_53,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_62,-DNRF52_PAN_63,-DNRF52_PAN_64,-DCONFIG_GPIO_AS_PINRESET,-DS132,-DNRF_SD_BLE_API_VERSION=3,-DBSP_DEFINES_ONLY,-DNRF52,-DSOFTDEVICE_PRESENT
  asm include: ..\..\..\config\direct_test_mode_pca10040_s132;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\bsp;..\..\..;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x59000
  memory RVCT9: RAM 0x20004128 size 0xbed8
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Documentation
    ../../../: license.txt
  group nRF_BLE
    ../../../../../../components/ble/ble_dtm/: ble_dtm.c ble_dtm_hw_nrf52.c
    ../../../../../../components/libraries/bootloader/dfu/: nrf_dfu_settings.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c
    ../../../../../../components/libraries/crc32/: crc32.c
    ../../../../../../components/libraries/bootloader/dfu/: nrf_dfu_flash.c
    ../../../../../../components/libraries/fstorage/: fstorage.c
    ../../../../../../components/drivers_nrf/hal/: nrf_nvmc.c
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
target flash_s132_nrf52_3.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: s132_nrf52_3.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\direct_test_mode_pca10040_s132;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x200013c8 size 0xec38
software components: CMSIS:CORE 4.3.0, Device:Startup 8.9.0
